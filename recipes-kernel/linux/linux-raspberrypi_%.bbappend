FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}-${PV}:"

#SRC_URI += "file://"

#KBUILD_DEFCONFIG_raspberrypi ?= "bcmrpi_defconfig"

LOCALVERSION = "-home-automation"
